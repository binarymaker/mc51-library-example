# Keil uVision project gpio.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: gpio
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\mc51-library\drivers;..\..\mc51-library\stdint
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../../mc51-library/drivers/: gpio.c mc51-library.c
